# Keil uVision project IWDG.uvprojx, settings and files
target IWDG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IWDG +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\CONVERSION;..\HARDWARE\AMAP;..\HARDWARE\STMFLASH;..\HARDWARE\IWDG;..\HARDWARE\LCD;..\HARDWARE\USART3;..\HARDWARE\SIM868;..\HARDWARE\USART1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/CONVERSION/: conversion.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/SIM868/: sim868.c
    ../HARDWARE/USART1/: usart_1.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c
    ./: startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_crc.c
  group README
    ../: README.TXT
